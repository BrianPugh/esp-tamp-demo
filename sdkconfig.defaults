## sdkconfig.defaults
```kconfig
TAMP_ESP32_AUTO_RESET_TASK_WDT=y
CONFIG_COMPILER_OPTIMIZATION_PERF=y
CONFIG_TAMP_ESP32=y
```
